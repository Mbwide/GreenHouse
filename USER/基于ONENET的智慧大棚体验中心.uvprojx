# Keil uVision project 基于ONENET的智慧大棚体验中心.uvprojx, settings and files
target 工程 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\SYS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: stm32f10x_it.c delay.c usart1.c usart2.c timer1.c timer2.c timer3.c timer4.c wifi.c mqtt.c key.c dht11.c 28byj48.c bh1750.c rc522.c adc.c bmp280.c myiic.c control.c water.c led.c exti.c fan.c ds18b20.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_adc.c
  group SYS
    ../SYS/: sys.c
